# Keil uVision project HM.uvprojx, settings and files
target HM (ARM-ADS)
  device: MK64FX512xxx12 Freescale Semiconductor
  cpu: IROM(0x00000000,0x80000) IROM2(0x10000000,0x20000) IRAM(0x20000000,0x20000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: HM1712 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ./bin/middle_power.bin ./obj/middle_power.axf
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: --library_interface=armcc 

 --library_type=standardlib 

--c99

 --diag_suppress=1296,186
  c include: ..\..\..\..\..\..\twrk64f120m.uv4\debug\bsp\Generated_Code;..\..\..\..\..\..\twrk64f120m.uv4\debug\bsp\Sources;..\..\..\..\..\..\twrk64f120m.uv4\debug;..\..\..\..\..\..\twrk64f120m.uv4\debug\bsp\;..\..\..\..\..\..\twrk64f120m.uv4\debug\psp\
  asm define: _DEBUG=1
  asm misc: --cpreproc 

 --diag_suppress=1609,1581
  asm include: ..\..\..\..\..\..\twrk64f120m.uv4\debug\bsp\Generated_Code;..\..\..\..\..\..\twrk64f120m.uv4\debug\bsp\Sources;..\..\..\..\..\..\twrk64f120m.uv4\debug\;..\..\..\..\..\..\twrk64f120m.uv4\debug\bsp\;..\..\..\..\..\..\twrk64f120m.uv4\debug\psp\
  memory RVCT4: ROM 0x5000 size 0x80000
  memory RVCT5: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ..\..\..\..\..\..\twrk64f120m.uv4\debug\bsp\intflash.scf
  link misc: ..\..\..\..\..\..\twrk64f120m.uv4\debug\bsp\bsp.lib

..\..\..\..\..\..\twrk64f120m.uv4\debug\bsp\bsp.lib(vectors.o)

..\..\..\..\..\..\twrk64f120m.uv4\debug\psp\psp.lib

..\..\..\..\..\..\twrk64f120m.uv4\debug\psp\psp.lib(linker_symbols.o)

 --keep linker_symbols.o(KERNEL_DATA_START) 

 --keep linker_symbols.o(KERNEL_DATA_END) 

 --keep linker_symbols.o(BOOT_STACK) 

 --keep vectors.o(.vectors_rom) 

 --diag_suppress=6314,6329 

 --remove 

 --autoat
  group Source
    ../../../: main.c queue.c common_fun.c adc_ctrl.c ftm.c gpio.c common_inc.c EEPROM.c flash_rw.c api.c gs_protocol.c Thermostat.c system_MK64F12.c capture.c can_ctrl.c dac_ctrl.c uart_ctrl.c fpga_int.c time.c i2c_ctrl.c
  group readme
    ../../../readme/: readme.h
